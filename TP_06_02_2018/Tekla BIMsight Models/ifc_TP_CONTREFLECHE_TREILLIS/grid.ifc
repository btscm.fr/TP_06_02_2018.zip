Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: grid.ifc
Time: 2018-01-29T22:02:42
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures Educational 2017 Service Pack 2, IFC Export Version: 4.0.0.0 May 16 2017

# IfcSite, Undefined
RefElevation: 0 mm
