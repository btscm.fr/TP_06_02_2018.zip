Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: Charpente métallique.ifc
Time: 2018-01-29T22:02:37
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures Educational 2017 Service Pack 2, IFC Export Version: 4.0.0.0 May 16 2017

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: HEA200 (4)
In: Undefined
Description: HEA200; Material: STEEL/S235J0
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235J0; Profil: HEA200
Tekla Quantités - Volume: 0 m3; Surface par tonne: 26.9 m2; Hauteur: 190 mm; Largeur: 200 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TRAVERSE HAUTE | +8.360 | +8.550 | TH0(?) | TRAVERSE HAUTE | 359.8 | 1.7 | 9.9 | 8515 | 9.67304 | 0.0434691 | 341.232
TRAVERSE BASSE | +5.000 | +5.190 | TB0(?) | TRAVERSE BASSE | 298.1 | 1.4 | 8.2 | 7055 | 8.01448 | 0.0360158 | 282.724
TRAVERSE HAUTE | +8.360 | +8.550 | TH0(?) | TRAVERSE HAUTE | 298.1 | 1.4 | 8.2 | 7055 | 8.01448 | 0.0360158 | 282.724
TRAVERSE BASSE | +5.000 | +5.190 | TB0(?) | TRAVERSE BASSE | 359.8 | 1.7 | 9.9 | 8515 | 9.67304 | 0.0434691 | 341.232

# IfcBeam: L100*10 (8)
In: Undefined
Description: L100*10; Material: STEEL/S235J0
Tekla Commun - Repère d'assemblage: A0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: L100*10; Nom: ATTACHE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 25.9 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Poids (kg) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x ATTACHE | +8.390 | +8.520 | A0(?) | 2 | 130 | 0.0507 | 0.000247 | 1.93895
2 x ATTACHE | +8.260 | +8.360 | 347(?) | 3 | 200 | 0.078 | 0.00038 | 2.983
2 x ATTACHE | +5.030 | +5.160 | A0(?) | 2 | 130 | 0.0507 | 0.000247 | 1.93895
2 x ATTACHE | +4.900 | +5.000 | A0(?) | 3 | 200 | 0.078 | 0.00038 | 2.983

# IfcBeam: L70*7 (2)
In: Undefined
Description: L70*7; Material: STEEL/S235J0
Tekla Commun - Niveau bas: +5.010; Niveau haut: +5.080; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: L70*7; Nom: SUPPORT
Tekla Quantités - Volume: 0 m3; Surface par tonne: 36.9 m2; Hauteur: 70 mm; Largeur: 70 mm
Pset_BeamCommon - LoadBearing: yes; Reference: S0(?)
Name | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
SUPPORT | 49.7 | 0 | 1.9 | 6735 | 1.83192 | 0.00627028 | 49.2217
SUPPORT | 60.5 | 0.1 | 2.3 | 8195 | 2.22904 | 0.00762954 | 59.8919

# IfcBeam: PL10*120 (4)
In: Undefined
Description: PL10*120; Material: STEEL/S235J0
Tekla Commun - Repère de pièce: E0(?); Repère d'assemblage: E0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: PL10*120; Nom: ECLISSE
Tekla Quantités - Poids: 3.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 28.2 m2; Surface nette: 0.1 m2; Hauteur: 120 mm; Largeur: 10 mm; Longueur: 410 mm
Pset_BeamCommon - LoadBearing: yes; Reference: E0(?)
BaseQuantities - Length: 410 mm; OuterSurfaceArea: 0.109 m2; NetVolume: 0.000492 m3; NetWeight: 3.8622 kg
Name | Niveau bas | Niveau haut
2 x ECLISSE | +8.395 | +8.515
2 x ECLISSE | +5.035 | +5.155

# IfcBeam: PL10*150 (2)
In: Undefined
Description: PL10*150; Material: STEEL/S235J0
Tekla Commun - Niveau bas: -0.210; Niveau haut: -0.200; Repère de pièce: 42(?); Repère d'assemblage: PS2(?); Phase: 1; Classe: 3; Matériau: S235J0; Profil: PL10*150; Nom: PRESCELLEMENT PS24
Tekla Quantités - Poids: 4.2 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 28 m2; Surface nette: 0.1 m2; Hauteur: 150 mm; Largeur: 10 mm; Longueur: 350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 42(?)
BaseQuantities - Length: 350 mm; OuterSurfaceArea: 0.115094 m2; NetVolume: 0.000523 m3; NetWeight: 4.10555 kg

# IfcBeam: PL10*200 (2)
In: Undefined
Description: PL10*200; Material: STEEL/S235J0
Tekla Quantités - Poids: 6.4 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 27.4 m2; Surface nette: 0.2 m2; Hauteur: 200 mm; Largeur: 10 mm; Longueur: 410 mm
Pset_BeamCommon - LoadBearing: yes; Reference: E0(?)
Tekla Commun - Repère de pièce: E0(?); Repère d'assemblage: E0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: PL10*200; Nom: ECLISSE
BaseQuantities - Length: 410 mm; OuterSurfaceArea: 0.1762 m2; NetVolume: 0.00082 m3; NetWeight: 6.437 kg
Name | Niveau bas | Niveau haut
ECLISSE | +8.550 | +8.560
ECLISSE | +4.990 | +5.000

# IfcBeam: PL15*210, PLATINE
In: Undefined
Description: PL15*210; Material: STEEL/S235J0
Tekla Commun - Niveau bas: +7.499; Niveau haut: +8.049; Repère de pièce: 0(?); Repère d'assemblage: 0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: PL15*210; Nom: PLATINE
Tekla Quantités - Poids: 13.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 18.7 m2; Surface nette: 0.3 m2; Hauteur: 210 mm; Largeur: 15 mm; Longueur: 550 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 0(?)
BaseQuantities - Length: 550 mm; OuterSurfaceArea: 0.2538 m2; NetVolume: 0.0017325 m3; NetWeight: 13.6001 kg

# IfcBeam: PL15*90 (2)
In: Undefined
Description: PL15*90; Material: STEEL/S235J0
Pset_BeamCommon - LoadBearing: yes; Reference: 0(?)
Tekla Commun - Niveau bas: -0.580; Niveau haut: -0.565; Repère de pièce: 0(?); Repère d'assemblage: 0(?); Phase: 1; Classe: 3; Matériau: S235J0; Profil: PL15*90; Nom: PLAQUETTE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 22.6 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 15 mm; Longueur: 90 mm
BaseQuantities - Length: 90 mm; OuterSurfaceArea: 0.0216 m2; NetVolume: 0.0001215 m3; NetWeight: 0.953775 kg

# IfcBeam: TOLE8*60 (29)
In: Undefined
Description: TOLE8*60; Material: STEEL/S235J0
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: TOLE8*60; Nom: PLAQUETTE
Tekla Quantités - Poids: 0.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 40.4 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 8 mm; Longueur: 60 mm
Pset_BeamCommon - LoadBearing: yes; Reference: P0(?)
BaseQuantities - Length: 60 mm; OuterSurfaceArea: 0.00713225 m2; NetVolume: 0.0000225048 m3; NetWeight: 0.176663 kg
Name | Niveau bas | Niveau haut
PLAQUETTE | +7.658 | +7.718
PLAQUETTE | +7.202 | +7.262
3 x PLAQUETTE | +6.745 | +6.805
PLAQUETTE | +6.288 | +6.348
PLAQUETTE | +5.832 | +5.892
PLAQUETTE | +7.665 | +7.725
PLAQUETTE | +7.205 | +7.265
PLAQUETTE | +6.285 | +6.345
PLAQUETTE | +5.825 | +5.885
2 x PLAQUETTE | +7.558 | +7.618
2 x PLAQUETTE | +7.016 | +7.076
2 x PLAQUETTE | +6.474 | +6.534
2 x PLAQUETTE | +5.932 | +5.992
PLAQUETTE | +5.744 | +5.804
PLAQUETTE | +6.144 | +6.204
PLAQUETTE | +6.545 | +6.605
PLAQUETTE | +6.945 | +7.005
PLAQUETTE | +7.346 | +7.406
PLAQUETTE | +7.746 | +7.806
PLAQUETTE | +5.816 | +5.876
PLAQUETTE | +6.281 | +6.341
PLAQUETTE | +7.209 | +7.269
PLAQUETTE | +7.674 | +7.734

# IfcColumn: HEA200 (5)
In: Undefined
Description: HEA200; Material: STEEL/S235J0
Tekla Commun - Niveau bas: +5.200; Niveau haut: +8.350; Repère d'assemblage: M0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: HEA200; Nom: MONTANT
Tekla Quantités - Poids: 133.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 26.9 m2; Surface nette: 3.7 m2; Hauteur: 190 mm; Largeur: 200 mm; Longueur: 3150 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetVolume: 0.0160807 m3; NetWeight: 126.234 kg
Name | Repère de pièce = Reference | Length (mm) | OuterSurfaceArea (m2)
MONTANT | 581(?) | 3149.99 | 3.57839
MONTANT | 158(?) | 3150 | 3.5784
MONTANT | 157(?) | 3149.99 | 3.57839
MONTANT | 156(?) | 3149.99 | 3.57839
MONTANT | 232(?) | 3149.99 | 3.57839

# IfcColumn: IPE600 (2)
In: Undefined
Description: IPE600; Material: STEEL/S235J0
Tekla Commun - Niveau bas: -0.185; Niveau haut: +8.540; Phase: 1; Classe: 2; Matériau: S235J0; Profil: IPE600; Nom: POTEAU
Tekla Quantités - Poids: 1068.5 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface par tonne: 16.5 m2; Surface nette: 18 m2; Hauteur: 600 mm; Largeur: 220 mm; Longueur: 8725 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 8725 mm; OuterSurfaceArea: 17.5809 m2; NetVolume: 0.131782 m3; NetWeight: 1034.49 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POTEAU | 14(?) | PT0(?)
POTEAU | 26(?) | PT12(?)

# IfcColumn: L100*10 (4)
In: Undefined
Description: L100*10; Material: STEEL/S235J0
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: L100*10; Nom: ATTACHE
Tekla Quantités - Poids: 2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 25.9 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 100 mm; Longueur: 130 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 130 mm; OuterSurfaceArea: 0.0507 m2; NetVolume: 0.000247 m3; NetWeight: 1.93895 kg
Name | Niveau bas | Niveau haut
2 x ATTACHE | +8.390 | +8.520
2 x ATTACHE | +5.030 | +5.160

# IfcDiscreteAccessory: BECHE (2)
In: Undefined
Description: HEA120; Material: STEEL/S235J0
Tekla Commun - Niveau bas: -0.330; Niveau haut: -0.210; Repère de pièce: 201(?); Repère d'assemblage: PS2(?); Phase: 1; Classe: 3; Matériau: S235J0; Profil: HEA120; Nom: BECHE
Tekla Quantités - Poids: 2.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34 m2; Surface nette: 0.1 m2; Hauteur: 114 mm; Largeur: 120 mm; Longueur: 120 mm
Pset_PlateCommon - LoadBearing: yes; Reference: 201(?)
BaseQuantities - NetArea: 0.08124 m2; GrossArea: 0.08124 m2; CrossSectionArea: 0.002534 m2; NetVolume: 0.0002892 m3; GrossVolume: 0.00030408 m3

# IfcDiscreteAccessory: GOUSSET (12)
In: Undefined
Material: STEEL/S235J0
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235J0; Nom: GOUSSET
Tekla Quantités - Poids: 1.7 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Largeur: 8 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000064 m2
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface par tonne (m2) | Hauteur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GOUSSET | TOLE8*122 | +8.097 | +8.350 | 396(?) | A0(?) | 35.2 | 122.3 | 279.4 | 0.0590402 | 0.0341681 | 0.000213858
GOUSSET | TOLE8*133 | +5.200 | +5.453 | 395(?) | M0(?) | 35 | 133 | 282.6 | 0.0629307 | 0.037605 | 0.000228977
GOUSSET | TOLE8*136 | +8.106 | +8.350 | 394(?) | M0(?) | 35 | 135.6 | 281.6 | 0.0632132 | 0.0381956 | 0.000230114
GOUSSET | TOLE8*136 | +5.200 | +5.444 | 394(?) | M0(?) | 35 | 135.6 | 281.6 | 0.0632128 | 0.0381951 | 0.000230112
GOUSSET | TOLE8*127 | +8.084 | +8.350 | 393(?) | M0(?) | 35.1 | 127.4 | 284.4 | 0.0622175 | 0.0362456 | 0.000226069
2 x GOUSSET | TOLE8*127 | +5.200 | +5.466 | 393(?) | M0(?) | 35.1 | 127.4 | 284.4 | 0.0622174 | 0.0362456 | 0.000226069
GOUSSET | TOLE8*127 | +8.084 | +8.350 | 393(?) | M0(?) | 35.1 | 127.4 | 284.4 | 0.0622174 | 0.0362455 | 0.000226069
GOUSSET | TOLE8*137 | +5.200 | +5.423 | 392(?) | M0(?) | 35 | 136.5 | 283.4 | 0.0634448 | 0.0386864 | 0.000230994
GOUSSET | TOLE8*137 | +8.127 | +8.350 | 392(?) | M0(?) | 35 | 136.5 | 283.4 | 0.063445 | 0.0386869 | 0.000230994
GOUSSET | TOLE8*138 | +5.200 | +5.431 | 391(?) | M0(?) | 35 | 138 | 280.4 | 0.0634576 | 0.0386934 | 0.00023106
GOUSSET | TOLE8*126 | +8.119 | +8.350 | 390(?) | A0(?) | 35.1 | 126.5 | 276.1 | 0.0593226 | 0.0349111 | 0.000215043

# IfcDiscreteAccessory: PLAQUETTE (8)
In: Undefined
Description: PL15*90; Material: STEEL/S235J0
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 22.6 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 15 mm; Longueur: 90 mm
Tekla Commun - Repère d'assemblage: PS2(?); Phase: 1; Classe: 3; Matériau: S235J0; Profil: PL15*90; Nom: PLAQUETTE
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.0216 m2; GrossArea: 0.0081 m2; CrossSectionArea: 0.000225 m2; NetVolume: 0.0001215 m3; GrossVolume: 0.0001215 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Reference
4 x PLAQUETTE | -0.185 | -0.170 | 41(?)
4 x PLAQUETTE | -0.580 | -0.565 | 34(?)

# IfcDiscreteAccessory: PLATINE (20)
In: Undefined
Material: STEEL/S235J0
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235J0; Nom: PLATINE
Tekla Quantités - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATINE | PL10*200 | +8.350 | +8.360 | 294(?) | M0(?) | 6.4 | 0.1 | 27.4 | 0.2 | 200 | 10 | 410 | 0.1762 | 0.1762 | 0.002 | 0.00082 | 0.00082
4 x PLATINE | PL10*200 | +8.350 | +8.360 | 287(?) | M0(?) | 3.1 | 0 | 28 | 0.1 | 200 | 10 | 200 | 0.0880013 | 0.0880013 | 0.002 | 0.000400006 | 0.000400006
4 x PLATINE | PL10*200 | +5.190 | +5.200 | 287(?) | M0(?) | 3.1 | 0 | 28 | 0.1 | 200 | 10 | 200 | 0.0880013 | 0.0880013 | 0.002 | 0.000400006 | 0.000400006
PLATINE | PL10*200 | +5.190 | +5.200 | 294(?) | M0(?) | 6.4 | 0.1 | 27.4 | 0.2 | 200 | 10 | 410 | 0.1762 | 0.1762 | 0.002 | 0.00082 | 0.00082
2 x PLATINE | PL15*103.5 | -0.185 | +0.009 | 27(?) | PT0(?) | 2.7 | 0 | 20.5 | 0.1 | 103.5 | 15 | 226.7 | 0.0562532 | 0.0568289 | 0.0015525 | 0.000348926 | 0.000351926
2 x PLATINE | PL15*103.5 | -0.185 | +0.009 | 27(?) | PT0(?) | 2.7 | 0 | 20.5 | 0.1 | 103.5 | 15 | 226.7 | 0.0562539 | 0.0568297 | 0.0015525 | 0.000348931 | 0.000351931
PLATINE | PL15*300 | -0.200 | -0.185 | 29(?) | PT0(?) | 11 | 0.1 | 18.7 | 0.2 | 300 | 15 | 310 | 0.2043 | 0.2043 | 0.0045 | 0.001395 | 0.001395
2 x PLATINE | PL15*103.5 | -0.185 | +0.009 | 27(?) | PT12(?) | 2.7 | 0 | 20.5 | 0.1 | 103.5 | 15 | 226.7 | 0.0562532 | 0.0568289 | 0.0015525 | 0.000348926 | 0.000351926
2 x PLATINE | PL15*103.5 | -0.185 | +0.009 | 27(?) | PT12(?) | 2.7 | 0 | 20.5 | 0.1 | 103.5 | 15 | 226.7 | 0.0562539 | 0.0568297 | 0.0015525 | 0.000348931 | 0.000351931
PLATINE | PL15*300 | -0.200 | -0.185 | 29(?) | PT12(?) | 11 | 0.1 | 18.7 | 0.2 | 300 | 15 | 310 | 0.2043 | 0.2043 | 0.0045 | 0.001395 | 0.001395

# IfcDiscreteAccessory: RAIDISSEUR (3)
In: Undefined
Description: TOLE10*100; Material: STEEL/S235J0
Tekla Commun - Repère d'assemblage: PT0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: TOLE10*100; Nom: RAIDISSEUR
Tekla Quantités - Poids: 4.2 kg; Volume: 0 m3; Surface par tonne: 28.5 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Surface supérieure totale (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAIDISSEUR | +7.504 | +8.044 | 360(?) | 0 | 540 | 0.119766 | 0.054 | 0.000536
RAIDISSEUR | +7.494 | +7.504 | 359(?) | 0.1 | 560 | 0.123049 | 0.056 | 0.000551
RAIDISSEUR | +8.044 | +8.054 | 359(?) | 0.1 | 560 | 0.123049 | 0.056 | 0.000551

# IfcDiscreteAccessory: TIGE D'ANCRAGE (8)
In: Undefined
Material: STEEL/S235J0
Tekla Commun - Repère d'assemblage: PS2(?); Phase: 1; Classe: 3; Matériau: S235J0; Nom: TIGE D'ANCRAGE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Poids (kg) | Surface par tonne (m2) | Hauteur (mm) = Largeur (mm) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x TIGE D'ANCRAGE | D24 | -0.250 | -0.100 | 218(?) | 0.5 | 23.7 | 24 | 150 | 0.012045 | 0.000432 | 0.0000648
4 x TIGE D'ANCRAGE | D22 | -0.600 | -0.250 | 210(?) | 1 | 24.7 | 22 | 350 | 0.0246409 | 0.000363 | 0.00012705

# IfcElementAssembly (11)
In: Undefined
PredefinedType: RIGID_FRAME
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
Steel Assembly | 1103.2 | -0.200 | +8.540 | C7/CA | PT0(?) | 310
Steel Assembly | 149.5 | +5.190 | +8.360 | C5-C6/CA | M0(?) | 410
Steel Assembly | 143 | +5.190 | +8.360 | C5/CA | M0(?) | 439.383
Steel Assembly | 143 | +5.190 | +8.360 | C4-C5/CA | M0(?) | 487.245
Steel Assembly | 4.7 | +8.119 | +8.360 | C4/CA | A0(?) | 239.383
Steel Assembly | 143 | +5.190 | +8.360 | C6-C7/CA | M0(?) | 438.352
Steel Assembly | 143 | +5.190 | +8.360 | C6/CA | M0(?) | 416.951
Steel Assembly | 4.7 | +8.097 | +8.360 | C7/CA | A0(?) | 213.193
Steel Assembly | 13.3 | -0.600 | -0.100 | C4/CA | PS2(?) | 500
Steel Assembly | 13.3 | -0.600 | -0.100 | C7/CA | PS2(?) | 500
Steel Assembly | 1090.4 | -0.200 | +8.540 | C4/CA | PT12(?) | 310

# IfcFastener (51)
In: Undefined
Tekla Soudure Commun - Niveau d'inspection NDT: Aucun; Coefficient de l'électrode: 0; Longueur de l'électrode: 0; Classification de l'électrode: Aucun; Type de procédé de soudage: Aucun; N° soudure: 0; Type d'assemblage: ATELIER; Type de cordon: Continu
Tekla Soudure dessus - Nombre d'incrément1: 0; Pas1: 0; Longueur1: 0 mm; Finition1: Aucun; Contour1: Aucun; Talon1: 0 mm; Ouverture racine1: 0 mm; Angle1: 0; Gorge effective1: 0 mm; Type1: W10
Tekla Soudure dessous - Nombre d'incrément2: 0; Pas2: 0; Longueur2: 0 mm; Finition2: Aucun; Contour2: Aucun; Talon2: 0 mm; Ouverture racine2: 0 mm; Angle2: 0; Gorge effective2: 0 mm
Name | Volume (m3) | Longueur (mm) = Logueur réelle1 (mm) | Linéaire/Périphérique | Surface section1 (m2) | Dimension1 (mm) | Longueur réelle2 (mm) | Surface section2 (m2) | Dimension2 (mm) | Type2
3 x Weld | 0.00003 | 500 | Droit | 0.00003 | 5 | 500 | 0.00003 | 5 | W10
2 x Weld | 0 | 10 | Droit | 0.00001 | 5 | 10 | 0.00001 | 5 | W10
4 x Weld | 0 | 70 | Droit | 0.00003 | 5 | 70 | 0.00003 | 5 | W10
10 x Weld | 0.00004 | 1167 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun
Weld | 0.00001 | 155.999 | Autour | 0 | 6 | 0 | 0 | 0 | Aucun
10 x Weld | 0.00001 | 176 | Autour | 0 | 6 | 0 | 0 | 0 | Aucun
Weld | 0.00001 | 156 | Autour | 0 | 6 | 0 | 0 | 0 | Aucun
2 x Weld | 0.00003 | 698 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun
4 x Weld | 0.00001 | 270 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun
4 x Weld | 0 | 62.6342 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun
8 x Weld | 0 | 83.5 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun
2 x Weld | 0.00002 | 624 | Autour | 0.00003 | 6 | 0 | 0 | 0 | Aucun

# IfcMechanicalFastener: Bolt assembly (102)
In: Undefined
Tekla Boulons - Quantité de rondelle: 0; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage
Name | NominalDiameter (mm) = Diamètre rondelle (mm) | NominalLength (mm) | Material = Standard | Type rondelle | Nom rondelle | Quantité d'écrou | Type écrou | Nom écrou | Diamètre du trou (mm) = Diamètre (mm) | Quantité | Longueur (mm) | Nom
Bolt assembly | 12 | 17.0004 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 14 | 10 | 17 | M12*25
Bolt assembly | 12 | 17.0008 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 14 | 8 | 17 | M12*25
29 x Bolt assembly | 16 | 22 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 1 | 22 | M16*30
Bolt assembly | 16 | 27 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 10 | 27 | M16*30
2 x Bolt assembly | 12 | 27 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 12 | 6 | 27 | M12*30
Bolt assembly | 12 | 20.0057 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 12 | 6 | 20 | M12*25
Bolt assembly | 12 | 19.9954 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 12 | 6 | 20 | M12*25
Bolt assembly | 12 | 20.0054 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 12 | 6 | 20 | M12*25
Bolt assembly | 12 | 19.9977 | 6.8 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 0 | E-6.8 | ECROU-M12-E-6.8 | 12 | 6 | 20 | M12*25
2 x Bolt assembly | 12 | 27 | 8.8 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 12 | 6 | 27 | M12*30
4 x Bolt assembly | 12 | 35 | 8.8 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 6 | E-8.8 | ECROU-M12-E-8.8 | 12 | 6 | 35 | M12*35
Bolt assembly | 16 | 19.9956 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 19.9958 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
4 x Bolt assembly | 16 | 27 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 27 | M16*30
Bolt assembly | 16 | 19.9961 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 20 | M16*30
Bolt assembly | 16 | 20.0001 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 19.9994 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 20 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 20 | M16*30
12 x Bolt assembly | 16 | 22 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 3 | 22 | M16*30
Bolt assembly | 16 | 19.9957 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 19.9964 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 20.0002 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
Bolt assembly | 16 | 20 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 4 | 20 | M16*30
3 x Bolt assembly | 16 | 29.0001 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
Bolt assembly | 16 | 29.0015 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
Bolt assembly | 16 | 19.9953 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 20 | M16*30
3 x Bolt assembly | 16 | 28.999 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
Bolt assembly | 16 | 29.0004 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
2 x Bolt assembly | 16 | 28.9975 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
2 x Bolt assembly | 16 | 28.9986 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 29 | M16*30
Bolt assembly | 16 | 20.0009 | 6.8 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 18 | 2 | 20 | M16*30
6 x Bolt assembly | 22 | 15 | 6.8 | PLA-6.8 | RONDELLE-M22-PLA-6.8 | 0 | E-6.8 | ECROU-M22-E-6.8 | 24 | 1 | 15 | M22*40
4 x Bolt assembly | 30 | 15 | 6.8 | PLA-6.8 | RONDELLE-M30-PLA-6.8 | 0 | E-6.8 | ECROU-M30-E-6.8 | 50 | 1 | 15 | M30*90
4 x Bolt assembly | 24 | 15 | 6.8 | PLA-6.8 | RONDELLE-M24-PLA-6.8 | 0 | E-6.8 | ECROU-M24-E-6.8 | 26 | 1 | 15 | M24*50
2 x Bolt assembly | 8 | 10 | 6.8 | PLA-6.8 | RONDELLE-M8-PLA-6.8 | 0 | E-6.8 | ECROU-M8-E-6.8 | 10 | 1 | 10 | M8*12
2 x Bolt assembly | 24 | 10 | 6.8 | PLA-6.8 | RONDELLE-M24-PLA-6.8 | 0 | E-6.8 | ECROU-M24-E-6.8 | 26 | 2 | 10 | M24*50

# IfcMember: UPN80 (12)
In: Undefined
Description: UPN80; Material: STEEL/S235J0
Tekla Commun - Repère de pièce: D0(?); Repère d'assemblage: D0(?); Phase: 1; Classe: 2; Matériau: S235J0; Profil: UPN80; Nom: DIAGONALE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 36.2 m2; Hauteur: 80 mm; Largeur: 45 mm
Pset_MemberCommon - LoadBearing: yes; Reference: D0(?)
BaseQuantities - CrossSectionArea: 0.0011 m2
Name | Niveau bas | Niveau haut | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x DIAGONALE | +5.247 | +8.303 | 36.4 | 1.4 | 4211.2 | 4211.19 | 1.3181 | 0.00457791 | 0.00463231 | 35.9366 | 36.3636
2 x DIAGONALE | +5.242 | +8.308 | 38.2 | 1.4 | 4426.2 | 4426.2 | 1.3854 | 0.00481235 | 0.00486882 | 37.7769 | 38.2202
2 x DIAGONALE | +5.271 | +8.279 | 30.1 | 1.1 | 3481 | 3480.99 | 1.08955 | 0.00378437 | 0.00382909 | 29.7073 | 30.0584
2 x DIAGONALE | +5.271 | +8.279 | 30 | 1.1 | 3480 | 3480 | 1.08924 | 0.00378437 | 0.00382799 | 29.7073 | 30.0498
2 x DIAGONALE | +5.255 | +8.295 | 33.8 | 1.3 | 3919.2 | 3919.24 | 1.22672 | 0.00426216 | 0.00431117 | 33.4579 | 33.8427
2 x DIAGONALE | +5.261 | +8.289 | 32.2 | 1.3 | 3731.1 | 3731.05 | 1.16782 | 0.00405792 | 0.00410416 | 31.8547 | 32.2176
